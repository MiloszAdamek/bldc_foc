<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\STM32G31RBTx_test_project.ewp</path>
  </project>
  <batchBuild />
</workspace>
